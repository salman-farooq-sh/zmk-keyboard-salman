## boards/shields/salman/Kconfig.defconfig
```kconfig
if SHIELD_SALMANS_BOARD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Salman's Board"

endif
```
